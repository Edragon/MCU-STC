# Keil uVision project Serial-1.uvproj, settings and files
target Serial-1 (MCS-51)
  device: STC8F2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Serial-1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: Serial-1.c
